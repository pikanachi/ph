# Keil uVision project p3.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: SWI.s Retarget.c softI.h softI.c FIQ.s
  group Source Code
    ./: main.c cola.h evento.h evento.c cola.c planificador.c planificador.h
  group gestor_IO
    ./: gestor_IO.c gestor_IO.h
  group gestor_pulsacion
    ./: gestor_pulsacion.c gestor_pulsacion.h
  group gestor_energia
    ./: gestor_energia.c gestor_energia.h
  group gestor_alarmas
    ./: gestor_alarmas.c gestor_alarmas.h
  group sudoku
    ./: sudoku.c tableros.h celda.h sudoku.h
  group gpio
    ./: gpio.h gpio.c
  group buttons
    ./: buttons.c buttons.h
  group idle_pwdwn
    ./: idle_pwdwn.h idle_pwdwn.c
  group timers
    ./: timers.h timers.c
  group relojes
    ./: relojes.c relojes.h
  group Serial_port
    ./: Serial_port.c Serial_port.h
